IO0DIR EQU 0XE0028008
IO0SET EQU 0XE0028004
IO0CLR EQU 0XE002800C
  AREA CHANG, CODE, READONLY
	EXPORT __main
__main
	ENTRY
		LDR R1,=IO0DIR
		LDR R0,=0X900
		STR R0,[R1]
		LDR R2,=IO0CLR
		LDR R3,=IO0SET
		;LDR R5,=0X800
		LDR R6,=0X100
		STR R0,[R2]
BACK	STR R6,[R3]
		BL delay
		STR R0,[R3]
		BL delay1
		STR R0,[R3]
		BL delay2
		B BACK
delay	LDR R4,=0X2FFF
delay1 	LDR R4,=0X2FFFFF
delay2  LDR R4,=0X2FFFFFFF
up		SUBS R4,R4,#1
		BNE up
		BX LR
		END